BATCH MODE INSTRUCTIONS ...............                                                             
Batch for evaluating Shuttle Coulomb Damper stability
! This batch set generates models for the Space Shuttle Ascent Stage-2 that will be 
! used for non-linear stability analysis using the Describing Function Method.
!
Flight Vehicle   : Shuttle Second Stage with Payload Damper, at T=123 sec
Actuator Model   : Shuttle Main Engine Hydraulic Actuator (Type-I)
System Connection: Actuators/TVC (Second Stage)  
Transf-Function  : Sensor Dynamics
System Connection: Plant Model, Vehicle/Actuators/Sensors
S-Z-Transform    : Plant Model, Vehicle/Actuators/Sensors (Z-Transform T=0.04)
S-Z-Transform    : Plant Model, Vehicle/Actuators/Sensors (Z-Transform T=0.002)
Transf-Function  : Shuttle Stage-2 Continuous Flight Control System
Transf-Function  : Shuttle Stage-2 Discrete Flight Control System
To Matlab Format : Plant Model, Vehicle/Actuators/Sensors
To Matlab Format : Plant Model, Vehicle/Actuators/Sensors (Z-Transform T=0.04)
To Matlab Format : Plant Model, Vehicle/Actuators/Sensors (Z-Transform T=0.002)
To Matlab Format : Shuttle Stage-2 Continuous Flight Control System             
To Matlab Format : Shuttle Stage-2 Discrete Flight Control System             
--------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Shuttle Second Stage with Payload Damper, at T=123 sec
! This is a Second Stage Shuttle Ascent model at T=123 sec, after solid booster separation.
! It will be used in flexible payload analysis with a non-linear Coulomb Damper. There are 
! two dampers whose two ends are attached to both the vehicle and the payload. Seven engines
! are defined. Only the first 3 engines are real, the actual 3 SSME's. Engines 4-7 are only
! force application points used to apply the coulomb damper forces, both on the payload and 
! on the vehicle. There are 10 translational sensors. The first two are accelerometers in
! Z and Y directions. Sensors 3-6 measure Displacement in the Z direction, and sensors 7-10 
! measure Velocity in the Z direction at the two ends of the two dampers. They measure the 
! relative motion between vehicle and payload across the dampers used for calculating the 
! damper forces.
Body Axes Output,Attitude=Rate Integral,Without GAFD, No Turn Coordination  
  
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :  0.418209E+05 32.1          0.20896E+08
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :  0.604722E+7  0.873354E+8   0.829562E+8  0.648080E+5  0.140521E+8  0.199420E+5   
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        : -95.194       0.0619       -38.847
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :  4.25         4217.4        31.37        0.153155E+06    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :  28.77        28.87         0.14         8.484
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :  2.78         0.1           0.0          0.0    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   : -178.6        26.3          90.4         0.043        0.2825      -0.026
Wind Gust Vel wrt Vehicle (Azim & Elev) angles, or Force (lb), location, Torque (ft-lb)  :  Gust         45.0          90.0    
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :  2690.0       39.56         78.05   
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} : -95.194       0.0619       -38.847       0.0000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.1435       0.00314159    0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}: -0.003       -0.031765      0.0000      -0.0022689    0.0000       0.0000       0.0000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:  0.013       -0.0292866     0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}: -0.00173     -0.0045125     0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:  0.05586     -0.0148456     0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:  0.00152      0.00867568    0.0000       0.0000       0.0000       0.0000    

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  0   NO TWD  

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  7   WITH TWD  

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : SSME Top-Cent   Gimbaling only
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  488688.0      488688.0  
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -14.0          0.0          10.0         10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  210.0         4032.0       3.0  
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -182.16        0.0         -64.94    
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : SSME Left       Gimbaling only
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  488688.0      488688.0  
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -10.8          3.5          10.0         10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  210.0         4032.0       3.0  
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -184.1        -4.4         -56.33   
TVC Engine No:  3                                (Gimbaling  Throttling   Single_Gimbal) : SSME Right      Gimbaling only
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  488688.0      488688.0  
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -10.8         -3.5          10.0         10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  210.0         4032.0       3.0  
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -184.1        +4.4         -56.33    
Engine No:      4                                (Gimbaling  Throttling   Single_Gimbal) : Left Dampr Vehi  Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0            350.0 
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -90.0           0.0         0.0          0.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  0.0            0.0         0.0  
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -166.08        -7.29       -65.91    
Engine No:      5                                (Gimbaling  Throttling   Single_Gimbal) : Right Dampr Vehi Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0            350.0 
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -90.0           0.0         0.0          0.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  0.0            0.0         0.0  
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -166.08        +7.29       -65.91    
Engine No:      6                                (Gimbaling  Throttling   Single_Gimbal) : Left Dampr Payld Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0            350.0 
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): +90.0           0.0         0.0          0.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  0.0            0.0         0.0  
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -166.08        -7.00       -67.83    
Engine No:      7                                (Gimbaling  Throttling   Single_Gimbal) : Right Dampr Payl Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.0            350.0 
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): +90.0           0.0         0.0          0.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  0.0            0.0         0.0  
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -166.08        +7.00       -67.83    

Number of Gyros, (Attitude and Rate)                                                     :  3
Gyro No  1 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Roll   Rate          -93.62    0.0   -61.53               
Gyro No  2 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Pitch  Rate          -93.62    0.0   -61.53                
Gyro No  3 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Yaw    Rate          -93.62    0.0   -61.53                 

Number of Accelerometers, Along Axis: (x,y,z)                                            : 10
Acceleromet No  1 Axis:(X,Y,Z), (Z Acceleration, Flex and Rigid),   (N2311)              :  Z-axis Accelerat.    -93.62    0.0   -61.53             
Acceleromet No  2 Axis:(X,Y,Z), (Y Acceleration, Flex and Rigid),   (N2311)              :  Y-axis Accelerat.    -93.62    0.0   -61.53             
Acceleromet No  3 Axis:(X,Y,Z), (Flex Position Only, No Rig-Body),  (Vehicle Left N3102) :  Z-axis Pos.Flex      -166.08  -7.29  -65.91             
Acceleromet No  4 Axis:(X,Y,Z), (Flex Position Only, No Rig-Body),  (Vehicle Rght N3101) :  Z-axis Pos.Flex      -166.08  +7.29  -65.91             
Acceleromet No  5 Axis:(X,Y,Z), (Flex Position Only, No Rig-Body),  (Paylod Left N3103)  :  Z-axis Pos.Flex      -166.08  -7.00  -67.83             
Acceleromet No  6 Axis:(X,Y,Z), (Flex Position Only, No Rig-Body),  (Paylod Right N294)  :  Z-axis Pos.Flex      -166.08  +7.00  -67.83             
Acceleromet No  7 Axis:(X,Y,Z), (Flex Velocity Only, No Rig-Body),  (Vehicle Left N3102) :  Z-axis Vel.Flex      -166.08  -7.29  -65.91             
Acceleromet No  8 Axis:(X,Y,Z), (Flex Velocity Only, No Rig-Body),  (Vehicle Rght N3101) :  Z-axis Vel.Flex      -166.08  +7.29  -65.91             
Acceleromet No  9 Axis:(X,Y,Z), (Flex Velocity Only, No Rig-Body),  (Paylod Left N3103)  :  Z-axis Vel.Flex      -166.08  -7.00  -67.83             
Acceleromet No 10 Axis:(X,Y,Z), (Flex Velocity Only, No Rig-Body),  (Paylod Right N294)  :  Z-axis Vel.Flex      -166.08  +7.00  -67.83             

Number of Vane Sensors, (Measuring Alpha or Beta)                                        :  0

Number of Slosh Modes                                                                    :  2
LOX Slosh Mass (slugs), Frequ Wy,Wz 1g (rad/s), Damp (zeta-y-z), Locat {Xsl,Ysl,Zsl} (ft):  6024.4  2.215  2.215  0.002  0.002  -64.672   0.0  -33.33    
LH2 Slosh Mass (slugs), Frequ Wy,Wz 1g (rad/s), Damp (zeta-y-z), Locat {Xsl,Ysl,Zsl} (ft):  511.06  2.102  2.102  0.005  0.005  -125.338  0.0  -33.33      

Number of Bending Modes                                                                  : 27
Shuttle Second Stage with Payload Damper, at T=123 sec, Mixed Modes                                  
--------------------------------------------------------------------------------------------------------------------------------
ACTUATOR INPUT DATA ............ HYDRAULIC TYPE B
Shuttle Main Engine Hydraulic Actuator (Type-I)
! This actuator model is used for the three Shuttle main engines to 
! gimbal the engines in pitch and yaw 
Symbol       Parameter Description               (Units)     Value
C(s)   Order of Compensat:(0,1,2), Coefficients   (---)      0
Kav    Total Gain of Amplifier + Torque Motor  (ft-lb/rad)  0.91000
Kact   Power Valve and Actuator Gain .........(ft/s/ft-lb)   53.950
Kt     Piston Ram Stiffness ...................  (lb/ft)    0.20280E+07
R      Moment Arm of Actuator Ram from Gimbal    (feet)      2.4800
Ie     Engine Inertia about Gimbal ............(ft-lb-s^2)   4516.0
Be     Engine Viscous Damping .................(ft-lb-sec)   16500.
Kb     Engine Gimbal Bearing Spring Constant   (ft-lb/rad)   27160.0
Kl     Engine Mount Structural Stiffness ......  (lb/ft)    0.27960E+07
Tc     Different. Pressure Feedbk Time Constant  (seconds)  0.12660
Kdpf   Differ Pressure Feedbk Linearizat. Gain  (ft-lb/lb)  0.40400E-06
Kfb    Position Feedback Gain ................. (rad/feet)  0.4
--------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Actuators/TVC (Second Stage)
! The Following system consists of Pitch and Yaw Actuators and the TVC for the 3 Engines.
! The System Inputs are the 3 flight control commands: DPTVC, DQTVC, DRTVC, the 3 
! pitch load-torques: TLY1, TLY2, TLY3, and the 3 yaw load-torques: TLZ1, TLZ2, TLZ3  
! The first 6 Outputs are Pitch and Yaw Deflections, and the last  6 Outputs are Pitch 
! and Yaw Accelerations
Titles of Systems to be Combined
Title 1 Shuttle Main Engine Hydraulic Actuator (Type-I)
Title 2 Shuttle Main Engine Hydraulic Actuator (Type-I)
Title 3 Shuttle Main Engine Hydraulic Actuator (Type-I)
Title 4 Shuttle Main Engine Hydraulic Actuator (Type-I)
Title 5 Shuttle Main Engine Hydraulic Actuator (Type-I)
Title 6 Shuttle Main Engine Hydraulic Actuator (Type-I)
SYSTEM INPUTS TO SUBSYSTEM  1                                           DY1
System Input  2 to Subsystem  1, Input  1, Gain= 1.071
System Input  4 to Subsystem  1, Input  2, Gain= 1.0                    TLY1
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  2                                           DY2
System Input  1 to Subsystem  2, Input  1, Gain= -0.45                  KLMPS
System Input  2 to Subsystem  2, Input  1, Gain= 1.071                  KMMPS
System Input  5 to Subsystem  2, Input  2, Gain= 1.0                    TLY2
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  3                                           DY3
System Input  1 to Subsystem  3, Input  1, Gain= +0.45                  KLMPS
System Input  2 to Subsystem  3, Input  1, Gain= 1.071                  KMMPS
System Input  6 to Subsystem  3, Input  2, Gain= 1.0                    TLY3
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  4                                           DZ1
System Input  1 to Subsystem  4, Input  1, Gain= -0.337                 KLMPS*0.75
System Input  3 to Subsystem  4, Input  1, Gain= 1.13                   KNMPS
System Input  7 to Subsystem  4, Input  2, Gain= 1.0                    TLZ1
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  5                                           DZ2
System Input  3 to Subsystem  5, Input  1, Gain= 1.13                   KNMPS
System Input  8 to Subsystem  5, Input  2, Gain= 1.0                    TLZ2
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  6                                           DZ3
System Input  3 to Subsystem  6, Input  1, Gain= 1.13                   KNMPS
System Input  9 to Subsystem  6, Input  2, Gain= 1.0                    TLZ3
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1
System Output  1 from Subsystem  1, Output  1, Gain= 1.0                dy1
System Output  7 from Subsystem  1, Output  3, Gain= 1.0                dy1_dd
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2
System Output  2 from Subsystem  2, Output  1, Gain= 1.0                dy2
System Output  8 from Subsystem  2, Output  3, Gain= 1.0                dy2_dd
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  3
System Output  3 from Subsystem  3, Output  1, Gain= 1.0                dy3
System Output  9 from Subsystem  3, Output  3, Gain= 1.0                dy3_dd
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  4
System Output  4 from Subsystem  4, Output  1, Gain= 1.0                dz1
System Output 10 from Subsystem  4, Output  3, Gain= 1.0                dz1_dd
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  5
System Output  5 from Subsystem  5, Output  1, Gain= 1.0                dz2
System Output 11 from Subsystem  5, Output  3, Gain= 1.0                dz2_dd
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  6
System Output  6 from Subsystem  6, Output  1, Gain= 1.0                dz3
System Output 12 from Subsystem  6, Output  3, Gain= 1.0                dz3_dd
..............................................................................
Definitions of Inputs  =   9
Roll FCS Command (DPTVC)
Pitch FCS Command (DQTVC)
Yaw FCS Command (DRTVC)
Engine 1 Pitch Load-Torque TLY1
Engine 2 Pitch Load-Torque TLY2
Engine 3 Pitch Load-Torque TLY3
Engine 1 Yaw Load-Torque TLZ1
Engine 2 Yaw Load-Torque TLZ2
Engine 3 Yaw Load-Torque TLZ3

Definitions of Outputs =  12
Engine 1 Pitch Deflection (rad)
Engine 2 Pitch Deflection (rad)
Engine 3 Pitch Deflection (rad)
Engine 1 Yaw Deflection (rad)
Engine 2 Yaw Deflection (rad)
Engine 3 Yaw Deflection (rad)
Engine 1 Pitch Accelerat (rad/sec^2)
Engine 2 Pitch Accelerat (rad/sec^2)
Engine 3 Pitch Accelerat (rad/sec^2)
Engine 1 Yaw Accelerat (rad/sec^2)
Engine 2 Yaw Accelerat (rad/sec^2)
Engine 3 Yaw Accelerat (rad/sec^2)
--------------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Sensor Dynamics
! Roll, Pitch, Yaw Attitude and Rate Sensors used for Flight Control
Continuous
TF. Block #  1 Roll IMU Filter                                   Order of Numer, Denom=  1  1
Numer 0.00000     7.00000
Denom 1.00000     7.00000
TF. Block #  2 Roll Rate Gyro Filter                             Order of Numer, Denom=  1  1
Numer 0.00000     50.0000
Denom 1.00000     50.0000
TF. Block #  3 Pitch IMU Filter                                  Order of Numer, Denom=  1  1
Numer 0.00000     7.00000
Denom 1.00000     7.00000
TF. Block #  4 Pitch Rate Gyro Filter                            Order of Numer, Denom=  1  1
Numer 0.00000     50.0000
Denom 1.00000     50.0000
TF. Block #  5 Yaw IMU Filter                                    Order of Numer, Denom=  1  1
Numer 0.00000     7.00000
Denom 1.00000     7.00000
TF. Block #  6 Yaw Rate Gyro Filter                              Order of Numer, Denom=  1  1
Numer 0.00000     50.0000
Denom 1.00000     50.0000
------------------------------------------------------------------------------
Block #, from Input #, Gain:
   1     1     1.0
   2     2     1.0
   3     3     1.0
   4     4     1.0
   5     5     1.0
   6     6     1.0
...........................
Outpt #, from Block #, Gain:
   1     1     1.0
   2     2     1.0
   3     3     1.0
   4     4     1.0
   5     5     1.0
   6     6     1.0
...........................
Definitions of Inputs  =   6
Roll Attitude from Vehicle                                                                
Roll Rate from Vehicle                                                                
Pitch Attitude from Vehicle                                                                
Pitch Rate from Vehicle                                                                
Yaw Attitude from Vehicle                                                                
Yaw Rate from Vehicle                                                                
 
Definitions of Outputs =   6
Roll Attitude to FCS
Roll Rate to FCS
Pitch Attitude to FCS
Pitch Rate to FCS
Yaw Attitude to FCS
Yaw Rate to FCS
--------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....                                                       Comments
Plant Model, Vehicle/Actuators/Sensors 
! Combined Model of Vehicle, Actuators, TVC, and Sensor dynamics
Titles of Systems to be Combined
Title 1 Actuators/TVC (Second Stage)
Title 2 Shuttle Second Stage with Payload Damper, at T=123 sec
Title 3 Sensor Dynamics
SYSTEM INPUTS TO SUBSYSTEM  1                                                          Actuator
System Input  1 to Subsystem  1, Input  1, Gain= 1.0                                   DP_tvc
System Input  2 to Subsystem  1, Input  2, Gain= 1.0                                   DQ_tvc
System Input  3 to Subsystem  1, Input  3, Gain= 1.0                                   DR_tvc
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  2                                                          Vehicle
System Input  4 to Subsystem  2, Input 17, Gain= 1.0                                   V-Gust
System Input  5 to Subsystem  2, Input 13, Gain= 1.0                                   Coul_Damp Force Bot Left 3102
System Input  5 to Subsystem  2, Input 15, Gain= 1.0                                   Coul_Damp Force Top Left 3103
System Input  6 to Subsystem  2, Input 14, Gain= 1.0                                   Coul_Damp Force Bot Rght 3103
System Input  6 to Subsystem  2, Input 16, Gain= 1.0                                   Coul_Damp Force Top Rght 294
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  3                                                       Sensors (IMU, Gyros)
Via Matrix +I6
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                                       Vehicle
System Output  7 from Subsystem  2, Output  7, Gain= 1.0                               alfa
System Output  8 from Subsystem  2, Output  8, Gain= 1.0                               beta
System Output  9 from Subsystem  2, Output 15, Gain= 1.0                               Nz
System Output 10 from Subsystem  2, Output 16, Gain= 1.0                               Ny
System Output 11 from Subsystem  2, Output 17, Gain= 1.0                               Coul_Damp Bot(Veh) Left 3102 - Positions
System Output 11 from Subsystem  2, Output 19, Gain=-1.0                               Coul_Damp Top(Pay) Left 3103
System Output 12 from Subsystem  2, Output 18, Gain= 1.0                               Coul_Damp Bot(Veh) Rght 3101 -
System Output 12 from Subsystem  2, Output 20, Gain=-1.0                               Coul_Damp Top(Pay) Rght 294
System Output 13 from Subsystem  2, Output 21, Gain= 1.0                               Coul_Damp Bot(Veh) Left 3102 - Rates
System Output 13 from Subsystem  2, Output 23, Gain=-1.0                               Coul_Damp Top(Pay) Left 3103
System Output 14 from Subsystem  2, Output 22, Gain= 1.0                               Coul_Damp Bot(Veh) Rght 3101 -
System Output 14 from Subsystem  2, Output 24, Gain=-1.0                               Coul_Damp Top(Pay) Rght 294
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  2                                                Actuat to Vehicle
Subsystem  1, Output  1 to Subsystem  2, Input  1, Gain= 1.0                           dy1
Subsystem  1, Output  2 to Subsystem  2, Input  2, Gain= 1.0                           dy2
Subsystem  1, Output  3 to Subsystem  2, Input  3, Gain= 1.0                           dy3
Subsystem  1, Output  7 to Subsystem  2, Input  4, Gain= 1.0                           dy1_dd
Subsystem  1, Output  8 to Subsystem  2, Input  5, Gain= 1.0                           dy2_dd
Subsystem  1, Output  9 to Subsystem  2, Input  6, Gain= 1.0                           dy3_dd
Subsystem  1, Output  4 to Subsystem  2, Input  7, Gain= 1.0                           dz1
Subsystem  1, Output  5 to Subsystem  2, Input  8, Gain= 1.0                           dz2
Subsystem  1, Output  6 to Subsystem  2, Input  9, Gain= 1.0                           dz3
Subsystem  1, Output 10 to Subsystem  2, Input 10, Gain= 1.0                           dz1_dd
Subsystem  1, Output 11 to Subsystem  2, Input 11, Gain= 1.0                           dz2_dd
Subsystem  1, Output 12 to Subsystem  2, Input 12, Gain= 1.0                           dz3_dd
..............................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  3                                                Vehicle to Sensors
Subsystem  2, Output  1 to Subsystem  3, Input  1, Gain= 1.0                           phi
Subsystem  2, Output  3 to Subsystem  3, Input  3, Gain= 1.0                           theta
Subsystem  2, Output  5 to Subsystem  3, Input  5, Gain= 1.0                           psi
Subsystem  2, Output 12 to Subsystem  3, Input  2, Gain= 1.0                           p-flex
Subsystem  2, Output 13 to Subsystem  3, Input  4, Gain= 1.0                           q-flex
Subsystem  2, Output 14 to Subsystem  3, Input  6, Gain= 1.0                           r-flex
..............................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  1                                                Vehicle to Actuator (Eng Load-Torque)
Subsystem  2, Output 25 to Subsystem  1, Input  4, Gain= 1.0                           TLY-1
Subsystem  2, Output 26 to Subsystem  1, Input  5, Gain= 1.0                           TLY-2
Subsystem  2, Output 27 to Subsystem  1, Input  6, Gain= 1.0                           TLY-3
Subsystem  2, Output 28 to Subsystem  1, Input  7, Gain= 1.0                           TLZ-1
Subsystem  2, Output 29 to Subsystem  1, Input  8, Gain= 1.0                           TLZ-2
Subsystem  2, Output 30 to Subsystem  1, Input  9, Gain= 1.0                           TLZ-3
..............................................................................
Definitions of Inputs  =   6
Roll FCS Command (DP-TVC)
Pitch FCS Command (DQ-TVC)
Yaw FCS Command (DR-TVC)
Wind-Gust Velocity (ft/sec)
Left Coulomb Damper Force                  
Right Coulomb Damper Force      
 
Definitions of Outputs =  14
Roll Attitude to FCS
Roll Rate to FCS
Pitch Attitude to FCS
Pitch Rate to FCS
Yaw Attitude to FCS
Yaw Rate to FCS
Angle of Attack, alpha (rad)
Angle of Sideslip, beta (rad)
Normal Accelerometer, Nz (ft/sec^2)
Lateral Accelerometer, Ny (ft/sec^2)
Left Damper Extension (ft)
Right Damper Extension (ft)
Left Damper Rate (ft/sec)
Right Damper Rate (ft/sec)
--------------------------------------------------------------------------------------------------------------------------------
TRANSFORM A SYSTEM (S-Z-W) ..... (Titles of the New and Old Systems)
Plant Model, Vehicle/Actuators/Sensors (Z-Transform T=0.04)                                 
! Transforms the Continuous Plant Model to Discrete Plant Model
! Using a 40 msec Sampling Period
Plant Model, Vehicle/Actuators/Sensors 
From S-plane to Z-plane using the Z-Transform, dT=  0.04
----------------------------------------------------------------------------------------------------
TRANSFORM A SYSTEM (S-Z-W) ..... (Titles of the New and Old Systems)
Plant Model, Vehicle/Actuators/Sensors (Z-Transform T=0.002)                                 
! Transforms the Continuous Plant Model to Discrete Plant Model
! Using a 2 msec Sampling Period
Plant Model, Vehicle/Actuators/Sensors 
From S-plane to Z-plane using the Z-Transform, dT=  0.002
----------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Shuttle Stage-2 Discrete Flight Control System
! The Following System is a combined Pitch and Lateral flight control 
! system (z-plane) for the Space Shuttle during Second Stage Ascent
Discrete, dt=  0.04
TF. Block #  1 MQO-(A)                                           Order of Numer, Denom=  2  2
Numer .3481644   -.4381397    .3003516                                                       
Denom 1.00000    -1.3926868   .6030635                                                       
TF. Block #  2 MQO-(B)                                           Order of Numer, Denom=  2  2
Numer .5192794   -.7480449    .4735804                                                       
Denom 1.00000    -1.3330898   .5779056                                                       
TF. Block #  3 MLLS2                                             Order of Numer, Denom=  2  2
Numer 1.138602   -1.5772626   .5841927                                                       
Denom 1.00000    -1.5772626   .7227952                                               
TF. Block #  4 MRO                                               Order of Numer, Denom=  2  2
Numer .1503906   -.03515626   .0097656
Denom 1.00000    -1.5         .625
TF. Block #  5 Pitch Integrator                                  Order of Numer, Denom=  1  1
Numer .04         0.00000
Denom 1.00000    -1.00000
TF. Block #  6 Yaw Integrator                                    Order of Numer, Denom=  1  1
Numer .04         0.00000
Denom 1.00000    -1.00000
TF. Block #  7 NRO-(a)                                           Order of Numer, Denom=  2  2
Numer .25        -.3387097    .2177419
Denom 1.00000    -1.548387    .6774194
TF. Block #  8 NRO-(b)                                           Order of Numer, Denom=  2  2
Numer .574359    -.6153846    .4512821
Denom 1.00000    -1.076923    .4871795
TF. Block #  9 NLLB                                              Order of Numer, Denom=  2  2
Numer 1.124138   -1.255172    .3793103
Denom 1.00000    -1.255172    .5034483
TF. Block # 10 NROFF                                             Order of Numer, Denom=  2  2
Numer .3397436   -.115385     .1858974
Denom 1.00000    -1.076923    .4871795
TF. Block # 11 Roll Integrator                                   Order of Numer, Denom=  1  1
Numer .04         0.00000
Denom 1.00000    -1.00000
TF. Block # 12 LPBC-(A)                                          Order of Numer, Denom=  2  2
Numer .5477522   -.6419696    .3149338
Denom 1.00000    -1.183954    .4046702
TF. Block # 13 LPBC-(B)                                          Order of Numer, Denom=  2  2
Numer .4923835   -.5179801    .3897718
Denom 1.00000    -1.434638    .7988138
TF. Block # 14 LRO                                               Order of Numer, Denom=  2  2
Numer .3573574    .1501501    .0330330
Denom 1.00000    -.8108108    .3513513
-------------------------------------------------------------------------------
Block #, from Input #, Gain
  5      2      0.4                                             the-error (KM_theta)
  1      2      0.4                                             the-error (KM_theta)
  1      5      1.0                                             q-error
  6      3      0.5                                             psi-error (KN_psi)
  7      3      0.5                                                       (KN_psi)
  7      6      1.0                                             yaw rate (r.gyro)
 11      3     -0.0                                             psi_error (KL_psi)
 11      1      0.5                                             phi-error (KL_phi)
 12      3     -0.0                                             psi_error (KL_psi)
 12      1      0.5                                             phi-error (KL_phi)
 12      4      1.0                                             p_orb
...........................
Block #, from Block #, Gain
  2      1      1.0                                             MQO (1 & 2)
  3      2      1.0                                             MLLS2
  4      3      1.0                                             MRO
  8      7      1.0                                             NRO (1 & 2)
  9      8      1.0                                             NLLB
 10      9      1.0                                             NROFF
 12     11      0.075                                           LPBC (1) * kl_int
 13     12      1.0                                             LPBC (2)
 14     13      1.0                                             LRO
...........................
Outpt #, from Block #, Gain
  1     10      1.6                                             P-TVC  KL_delpsi
  1     14      1.0
  2      5      0.106                                           Q-TVC  KM_int/KM_mps
  2      4      1.00000
  3      6      0.075                                           R-TVC  KN_int/KN_mps=0.075
  3     10      1.00000
...........................
Definitions of Inputs  =   6
Roll Attitude Error  (phi-err)
Pitch Attitude Error (theta-err)
Yaw Attitude Error   (psi-err)
Roll Rate Error  (p-err)
Pitch Rate Error (q-err)
Yaw Rate Error   (r-err)
 
Definitions of Outputs =   3
Roll FCS (DP-TVC)
Pitch FCS (DQ-TVC)
Yaw FCS (DR-TVC)
--------------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Shuttle Stage-2 Continuous Flight Control System
! The Following System is a combined Pitch and Lateral flight control 
! system (s-plane) for the Space Shuttle during Second Stage of Ascent
Continuous
TF. Block #  1 MQO-(A)                                           Order of Numer, Denom=  2  2
Numer 0.3481644   3.4805598   171.3888                                                       
Denom 1.0000000   12.643319   171.3888                                                       
TF. Block #  2 MQO-(B)                                           Order of Numer, Denom=  2  2
Numer 0.5192794   3.0         204.25                                                       
Denom 1.00000     13.708      204.25                                                       
TF. Block #  3 MLLS2                                             Order of Numer, Denom=  2  2
Numer 1.13860     16.149246   108.0641                                                       
Denom 1.00000     8.116       108.0641                                               
TF. Block #  4 MRO                                               Order of Numer, Denom=  2  2
Numer 0.1503906   6.05162484  99.21824
Denom 1.00000     11.7500907  99.21824
TF. Block #  5 Pitch Integrator                                  Order of Numer, Denom=  0  1
Numer 0.0         1.0
Denom 1.00000     0.0
TF. Block #  6 Yaw Integrator                                    Order of Numer, Denom=  0  1
Numer 0.0         1.0
Denom 1.00000     0.0
TF. Block #  7 NRO-(a)                                           Order of Numer, Denom=  2  2
Numer 0.25        2.33655      98.65377
Denom 1.00000     9.73662      98.65377
TF. Block #  8 NRO-(b)                                           Order of Numer, Denom=  2  2
Numer 0.574359    6.647751     378.0831
Denom 1.00000     17.978       378.0831
TF. Block #  9 NLLB                                              Order of Numer, Denom=  2  2
Numer 1.124138    25.628049    220.838
Denom 1.00000     17.1568      220.838
TF. Block # 10 NROFF                                             Order of Numer, Denom=  2  2
Numer 0.3397436   9.9372198    378.0826
Denom 1.00000     17.978       378.0826
TF. Block # 11 Roll Integrator                                   Order of Numer, Denom=  0  1
Numer 0.0         1.0
Denom 1.00000     0.0
TF. Block # 12 LPBC-(A)                                          Order of Numer, Denom=  2  2
Numer 0.5477522   10.34161     215.6798
Denom 1.00000     22.617       215.6798
TF. Block # 13 LPBC-(B)                                          Order of Numer, Denom=  2  2
Numer 0.4923835   5.536643     263.2319
Denom 1.00000     5.61568      263.2319
TF. Block # 14 LRO                                               Order of Numer, Denom=  2  2
Numer 0.3573574   20.478539    588.7849
Denom 1.00000     26.149       588.7849
-------------------------------------------------------------------------------
Block #, from Input #, Gain
  5      2      0.4                                             the-error (KM_theta)
  1      2      0.4                                             the-error (KM_theta)
  1      5      1.0                                             q-error
  6      3      0.5                                             psi-error (KN_psi)
  7      3      0.5                                                       (KN_psi)
  7      6      1.0                                             yaw rate (r.gyro)
 11      3     -0.0                                             psi_error (KL_psi)
 11      1      0.5                                             phi-error (KL_phi)
 12      3     -0.0                                             psi_error (KL_psi)
 12      1      0.5                                             phi-error (KL_phi)
 12      4      1.0                                             p_orb
...........................
Block #, from Block #, Gain
  2      1      1.0                                             MQO (1 & 2)
  3      2      1.0                                             MLLS2
  4      3      1.0                                             MRO
  8      7      1.0                                             NRO (1 & 2)
  9      8      1.0                                             NLLB
 10      9      1.0                                             NROFF
 12     11      0.075                                           LPBC (1) * kl_int
 13     12      1.0                                             LPBC (2)
 14     13      1.0                                             LRO
...........................
Outpt #, from Block #, Gain
  1     10      1.6                                             P-TVC  KL_delpsi
  1     14      1.0
  2      5      0.106                                           Q-TVC  KM_int/KM_mps
  2      4      1.00000
  3      6      0.075                                           R-TVC  KN_int/KN_mps=0.075
  3     10      1.00000
...........................
Definitions of Inputs  =   6
Roll Attitude Error  (phi-err)
Pitch Attitude Error (theta-err)
Yaw Attitude Error   (psi-err)
Roll Rate Error  (p-err)
Pitch Rate Error (q-err)
Yaw Rate Error   (r-err)
 
Definitions of Outputs =   3
Roll FCS (DP-TVC)
Pitch FCS (DQ-TVC)
Yaw FCS (DR-TVC)
--------------------------------------------------------------------------------------------------------------------------------
SELECTED MODAL DATA AND LOCATIONS USING MULTIPLE CRITERIA         
Shuttle Second Stage with Payload Damper, at T=123 sec, Mixed Modes                                  
! The Finite Elements Model does not include the Coulong Damper.
! The model has four nodes to connect at the two ends of the two dampers.
! Modes were selected using a compilation of multiple criteria  
! (a)- from TVC engines to pitch gyro, 
! (b)- symmetric forces on the vehicle along Z at the 2 damper attachments 
! to symmetric accelerations at the payload attachmets.                      
! (c)- antisymmetric Z-forces on the vehicle at the 2 damper attachments 
! to anti-symmetric accelerations at the payload attachmets.                      

MODE # 1/  7, Frequency (rad/sec), Damping (zeta), Generalized Mass=    9.0752       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077     0.15362D+00   0.12782D-02  -0.24250D+00   0.69584D-04  -0.89453D-02   0.69186D-04
Shuttle Main Engine # 2           2243     0.79232D-01   0.13871D-02  -0.25930D+00  -0.43284D-04  -0.88351D-02  -0.11605D-03
Shuttle Main Engine # 3           2080     0.79451D-01   0.12117D-02  -0.26014D+00   0.79560D-04  -0.97774D-02   0.10219D-03
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.13251D-01  -0.81907D-01   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.10628D-01  -0.81643D-01   0.00000D+00   0.00000D+00   0.00000D+00
Left Coulomb  Damper (payload     3103     0.11840D+00   0.39883D-03  -0.20333D+01   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (payload      294     0.11514D+00  -0.11015D-01  -0.20360D+01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168     0.44584D-01   0.00000D+00   0.00000D+00   0.24427D-03  -0.10604D-01  -0.32453D-03
Aft Payload Gyro (left)           2168     0.44584D-01   0.00000D+00   0.00000D+00   0.24427D-03  -0.10604D-01  -0.32453D-03
Aft Payload Gyro (left)           2168     0.44584D-01   0.00000D+00   0.00000D+00   0.24427D-03  -0.10604D-01  -0.32453D-03

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00   0.12908D-02  -0.98519D-02
Orbiter IMU/Accelerom (right)     2311     0.00000D+00   0.12908D-02  -0.98519D-02
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.13251D-01  -0.81907D-01
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.10628D-01  -0.81643D-01
Left Coulomb  Damper (payload     3103     0.11840D+00   0.39883D-03  -0.20333D+01
Right Coulomb Damper (payload      294     0.11514D+00  -0.11015D-01  -0.20360D+01
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.13251D-01  -0.81907D-01
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.10628D-01  -0.81643D-01
Left Coulomb  Damper (payload     3103     0.11840D+00   0.39883D-03  -0.20333D+01
Right Coulomb Damper (payload      294     0.11514D+00  -0.11015D-01  -0.20360D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00  -0.23727D-03  -0.32455D-01   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00  -0.38542D-03  -0.79081D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077     0.15362D+00   0.12782D-02  -0.24250D+00   0.69584D-04  -0.89453D-02   0.69186D-04

MODE # 2/  8, Frequency (rad/sec), Damping (zeta), Generalized Mass=    9.4117       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077    -0.69673D-03  -0.11869D+00   0.21129D-02  -0.35287D-02   0.78575D-04   0.29990D-03
Shuttle Main Engine # 2           2243     0.34073D-03  -0.89213D-01   0.17570D-01  -0.35216D-02  -0.21202D-04   0.15974D-03
Shuttle Main Engine # 3           2080    -0.12625D-02  -0.89319D-01  -0.13351D-01  -0.34372D-02  -0.68072D-04   0.27203D-03
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.94655D-01   0.24381D-01   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.94564D-01  -0.21434D-01   0.00000D+00   0.00000D+00   0.00000D+00
Left Coulomb  Damper (payload     3103     0.17086D-01   0.44947D-01  -0.61580D-01   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (payload      294    -0.18282D-01   0.45011D-01   0.55888D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168     0.11844D-03   0.00000D+00   0.00000D+00  -0.33881D-02   0.61501D-04   0.38185D-03
Aft Payload Gyro (left)           2168     0.11844D-03   0.00000D+00   0.00000D+00  -0.33881D-02   0.61501D-04   0.38185D-03
Aft Payload Gyro (left)           2168     0.11844D-03   0.00000D+00   0.00000D+00  -0.33881D-02   0.61501D-04   0.38185D-03

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.10966D+00  -0.25398D-02
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.10966D+00  -0.25398D-02
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.94655D-01   0.24381D-01
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.94564D-01  -0.21434D-01
Left Coulomb  Damper (payload     3103     0.17086D-01   0.44947D-01  -0.61580D-01
Right Coulomb Damper (payload      294    -0.18282D-01   0.45011D-01   0.55888D-01
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.94655D-01   0.24381D-01
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.94564D-01  -0.21434D-01
Left Coulomb  Damper (payload     3103     0.17086D-01   0.44947D-01  -0.61580D-01
Right Coulomb Damper (payload      294    -0.18282D-01   0.45011D-01   0.55888D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00  -0.15104D-02   0.58053D-04   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00  -0.21983D-02   0.91942D-03   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077    -0.69673D-03  -0.11869D+00   0.21129D-02  -0.35287D-02   0.78575D-04   0.29990D-03

MODE # 3/ 11, Frequency (rad/sec), Damping (zeta), Generalized Mass=    9.7279       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077    -0.12018D+00   0.46434D-03   0.14967D+00   0.23965D-04   0.72390D-02  -0.56797D-04
Shuttle Main Engine # 2           2243    -0.59898D-01  -0.27628D-03   0.16302D+00   0.97674D-04   0.71726D-02   0.91382D-04
Shuttle Main Engine # 3           2080    -0.60111D-01  -0.13282D-03   0.16433D+00   0.98057D-05   0.79316D-02  -0.74923D-04
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.92847D-02   0.21165D-01   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.97165D-02   0.21853D-01   0.00000D+00   0.00000D+00   0.00000D+00
Left Coulomb  Damper (payload     3103    -0.88318D-01  -0.29812D-02   0.19873D+01   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (payload      294    -0.84748D-01   0.86495D-02   0.19843D+01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168    -0.31995D-01   0.00000D+00   0.00000D+00  -0.12730D-03   0.87233D-02   0.28919D-03
Aft Payload Gyro (left)           2168    -0.31995D-01   0.00000D+00   0.00000D+00  -0.12730D-03   0.87233D-02   0.28919D-03
Aft Payload Gyro (left)           2168    -0.31995D-01   0.00000D+00   0.00000D+00  -0.12730D-03   0.87233D-02   0.28919D-03

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00   0.13705D-02  -0.96822D-02
Orbiter IMU/Accelerom (right)     2311     0.00000D+00   0.13705D-02  -0.96822D-02
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.92847D-02   0.21165D-01
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.97165D-02   0.21853D-01
Left Coulomb  Damper (payload     3103    -0.88318D-01  -0.29812D-02   0.19873D+01
Right Coulomb Damper (payload      294    -0.84748D-01   0.86495D-02   0.19843D+01
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.92847D-02   0.21165D-01
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.97165D-02   0.21853D-01
Left Coulomb  Damper (payload     3103    -0.88318D-01  -0.29812D-02   0.19873D+01
Right Coulomb Damper (payload      294    -0.84748D-01   0.86495D-02   0.19843D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00   0.23307D-03   0.27561D-01   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00  -0.55937D-03   0.34758D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077    -0.12018D+00   0.46434D-03   0.14967D+00   0.23965D-04   0.72390D-02  -0.56797D-04

MODE # 4/ 12, Frequency (rad/sec), Damping (zeta), Generalized Mass=    15.901       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077     0.38457D-03  -0.11604D+01  -0.39839D-03  -0.31801D-01   0.61663D-03  -0.40313D-02
Shuttle Main Engine # 2           2243     0.93614D-02  -0.91147D+00   0.15036D+00  -0.34255D-01   0.23797D-02   0.21961D-02
Shuttle Main Engine # 3           2080    -0.16042D-01  -0.91461D+00  -0.15274D+00  -0.31852D-01  -0.34620D-02   0.54964D-02
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.74680D+00   0.17714D+00   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.74696D+00  -0.16884D+00   0.00000D+00   0.00000D+00   0.00000D+00
Left Coulomb  Damper (payload     3103     0.87572D-01   0.46282D+01  -0.17522D+01   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (payload      294    -0.86962D-01   0.46301D+01   0.18135D+01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168     0.88318D-02   0.00000D+00   0.00000D+00  -0.29172D-01   0.12545D-02   0.89376D-02
Aft Payload Gyro (left)           2168     0.88318D-02   0.00000D+00   0.00000D+00  -0.29172D-01   0.12545D-02   0.89376D-02
Aft Payload Gyro (left)           2168     0.88318D-02   0.00000D+00   0.00000D+00  -0.29172D-01   0.12545D-02   0.89376D-02

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.10409D+01  -0.33671D-01
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.10409D+01  -0.33671D-01
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.74680D+00   0.17714D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.74696D+00  -0.16884D+00
Left Coulomb  Damper (payload     3103     0.87572D-01   0.46282D+01  -0.17522D+01
Right Coulomb Damper (payload      294    -0.86962D-01   0.46301D+01   0.18135D+01
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.74680D+00   0.17714D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.74696D+00  -0.16884D+00
Left Coulomb  Damper (payload     3103     0.87572D-01   0.46282D+01  -0.17522D+01
Right Coulomb Damper (payload      294    -0.86962D-01   0.46301D+01   0.18135D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00   0.60120D-03   0.92269D-03   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00  -0.12600D+00  -0.53789D-02   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077     0.38457D-03  -0.11604D+01  -0.39839D-03  -0.31801D-01   0.61663D-03  -0.40313D-02

MODE # 5/ 13, Frequency (rad/sec), Damping (zeta), Generalized Mass=    16.599       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077    -0.17706D+01  -0.73207D-03   0.14421D+01  -0.14616D-02   0.88259D-01  -0.76727D-03
Shuttle Main Engine # 2           2243    -0.10343D+01  -0.20168D-02   0.16091D+01   0.92984D-04   0.88380D-01   0.32135D-02
Shuttle Main Engine # 3           2080    -0.10398D+01   0.43449D-02   0.16279D+01  -0.21828D-02   0.11191D+00  -0.30071D-02
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.92978D-01  -0.37019D+00   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.96289D-01  -0.37760D+00   0.00000D+00   0.00000D+00   0.00000D+00
Left Coulomb  Damper (payload     3103    -0.16682D+01   0.26212D-01  -0.29795D+01   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (payload      294    -0.16691D+01  -0.77731D-02  -0.29904D+01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168    -0.60923D+00   0.00000D+00   0.00000D+00  -0.21281D-02   0.88998D-01  -0.13868D-02
Aft Payload Gyro (left)           2168    -0.60923D+00   0.00000D+00   0.00000D+00  -0.21281D-02   0.88998D-01  -0.13868D-02
Aft Payload Gyro (left)           2168    -0.60923D+00   0.00000D+00   0.00000D+00  -0.21281D-02   0.88998D-01  -0.13868D-02

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00   0.54201D-02  -0.72898D+00
Orbiter IMU/Accelerom (right)     2311     0.00000D+00   0.54201D-02  -0.72898D+00
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.92978D-01  -0.37019D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.96289D-01  -0.37760D+00
Left Coulomb  Damper (payload     3103    -0.16682D+01   0.26212D-01  -0.29795D+01
Right Coulomb Damper (payload      294    -0.16691D+01  -0.77731D-02  -0.29904D+01
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.92978D-01  -0.37019D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.96289D-01  -0.37760D+00
Left Coulomb  Damper (payload     3103    -0.16682D+01   0.26212D-01  -0.29795D+01
Right Coulomb Damper (payload      294    -0.16691D+01  -0.77731D-02  -0.29904D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00  -0.26271D-03   0.25015D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00  -0.20955D-02  -0.34660D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077    -0.17706D+01  -0.73207D-03   0.14421D+01  -0.14616D-02   0.88259D-01  -0.76727D-03

MODE # 6/ 15, Frequency (rad/sec), Damping (zeta), Generalized Mass=    19.502       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077    -0.46980D-02   0.21567D+00   0.75820D-02   0.11424D-01   0.80970D-03   0.20951D-01
Shuttle Main Engine # 2           2243    -0.13879D-01   0.21920D+00  -0.67264D-01   0.15060D-01  -0.78491D-02  -0.25350D-02
Shuttle Main Engine # 3           2080     0.73222D-02   0.22228D+00   0.88515D-01   0.14938D-01   0.65729D-02  -0.49204D-02
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.21008D+00  -0.19094D-01   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.20887D+00   0.20973D-01   0.00000D+00   0.00000D+00   0.00000D+00
Left Coulomb  Damper (payload     3103     0.46398D+00  -0.14727D+01  -0.34203D+00   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (payload      294    -0.46920D+00  -0.14719D+01   0.29402D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168    -0.15545D-01   0.00000D+00   0.00000D+00   0.55271D-02  -0.25447D-02  -0.12654D-01
Aft Payload Gyro (left)           2168    -0.15545D-01   0.00000D+00   0.00000D+00   0.55271D-02  -0.25447D-02  -0.12654D-01
Aft Payload Gyro (left)           2168    -0.15545D-01   0.00000D+00   0.00000D+00   0.55271D-02  -0.25447D-02  -0.12654D-01

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.24739D+01  -0.76684D-01
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.24739D+01  -0.76684D-01
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.21008D+00  -0.19094D-01
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.20887D+00   0.20973D-01
Left Coulomb  Damper (payload     3103     0.46398D+00  -0.14727D+01  -0.34203D+00
Right Coulomb Damper (payload      294    -0.46920D+00  -0.14719D+01   0.29402D+00
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.21008D+00  -0.19094D-01
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.20887D+00   0.20973D-01
Left Coulomb  Damper (payload     3103     0.46398D+00  -0.14727D+01  -0.34203D+00
Right Coulomb Damper (payload      294    -0.46920D+00  -0.14719D+01   0.29402D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00   0.11216D+00   0.48113D-04   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00  -0.26288D+00   0.25918D-02   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077    -0.46980D-02   0.21567D+00   0.75820D-02   0.11424D-01   0.80970D-03   0.20951D-01

MODE # 7/ 16, Frequency (rad/sec), Damping (zeta), Generalized Mass=    21.689       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077     0.75480D+00  -0.37487D-01   0.25017D+00   0.12234D-02  -0.12451D-01  -0.12750D-03
Shuttle Main Engine # 2           2243     0.62583D+00  -0.46944D-01   0.20235D+00   0.29114D-02  -0.17801D-01  -0.10622D-02
Shuttle Main Engine # 3           2080     0.62086D+00  -0.52530D-01   0.21672D+00   0.19200D-02  -0.20046D-01   0.24577D-02
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.11656D+00   0.40097D+00   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.55221D-01   0.42512D+00   0.00000D+00   0.00000D+00   0.00000D+00
Left Coulomb  Damper (payload     3103     0.88020D+00   0.85943D-01  -0.52736D+01   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (payload      294     0.90076D+00   0.74308D-01  -0.52360D+01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168     0.53369D+00   0.00000D+00   0.00000D+00  -0.45050D-04  -0.50810D-02   0.27028D-02
Aft Payload Gyro (left)           2168     0.53369D+00   0.00000D+00   0.00000D+00  -0.45050D-04  -0.50810D-02   0.27028D-02
Aft Payload Gyro (left)           2168     0.53369D+00   0.00000D+00   0.00000D+00  -0.45050D-04  -0.50810D-02   0.27028D-02

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00   0.18458D-01   0.94369D+00
Orbiter IMU/Accelerom (right)     2311     0.00000D+00   0.18458D-01   0.94369D+00
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.11656D+00   0.40097D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.55221D-01   0.42512D+00
Left Coulomb  Damper (payload     3103     0.88020D+00   0.85943D-01  -0.52736D+01
Right Coulomb Damper (payload      294     0.90076D+00   0.74308D-01  -0.52360D+01
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.11656D+00   0.40097D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.55221D-01   0.42512D+00
Left Coulomb  Damper (payload     3103     0.88020D+00   0.85943D-01  -0.52736D+01
Right Coulomb Damper (payload      294     0.90076D+00   0.74308D-01  -0.52360D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00  -0.23009D-02  -0.19497D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00   0.23936D-01   0.10914D+01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077     0.75480D+00  -0.37487D-01   0.25017D+00   0.12234D-02  -0.12451D-01  -0.12750D-03

MODE # 8/ 17, Frequency (rad/sec), Damping (zeta), Generalized Mass=    23.028       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077     0.37914D-02   0.20112D+01   0.62181D-02   0.29113D-01  -0.51889D-02   0.17652D-03
Shuttle Main Engine # 2           2243    -0.11655D+00   0.17710D+01  -0.19975D+00   0.45226D-01  -0.16298D-01  -0.21089D-01
Shuttle Main Engine # 3           2080     0.10455D+00   0.17796D+01   0.18496D+00   0.35364D-01   0.33767D-02  -0.31306D-01
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.10871D+01  -0.19959D+00   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.10984D+01   0.22351D+00   0.00000D+00   0.00000D+00   0.00000D+00
Left Coulomb  Damper (payload     3103     0.39324D-01  -0.78378D+00   0.18590D+00   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (payload      294    -0.27473D-01  -0.78419D+00  -0.30305D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168    -0.31813D-01   0.00000D+00   0.00000D+00   0.37902D-01  -0.43289D-02  -0.34223D-01
Aft Payload Gyro (left)           2168    -0.31813D-01   0.00000D+00   0.00000D+00   0.37902D-01  -0.43289D-02  -0.34223D-01
Aft Payload Gyro (left)           2168    -0.31813D-01   0.00000D+00   0.00000D+00   0.37902D-01  -0.43289D-02  -0.34223D-01

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.38640D+01  -0.12770D+00
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.38640D+01  -0.12770D+00
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.10871D+01  -0.19959D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.10984D+01   0.22351D+00
Left Coulomb  Damper (payload     3103     0.39324D-01  -0.78378D+00   0.18590D+00
Right Coulomb Damper (payload      294    -0.27473D-01  -0.78419D+00  -0.30305D+00
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.10871D+01  -0.19959D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.10984D+01   0.22351D+00
Left Coulomb  Damper (payload     3103     0.39324D-01  -0.78378D+00   0.18590D+00
Right Coulomb Damper (payload      294    -0.27473D-01  -0.78419D+00  -0.30305D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00   0.22596D+00  -0.12699D-02   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00  -0.93816D+00  -0.90951D-02   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077     0.37914D-02   0.20112D+01   0.62181D-02   0.29113D-01  -0.51889D-02   0.17652D-03

MODE # 9/ 20, Frequency (rad/sec), Damping (zeta), Generalized Mass=    29.714       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077     0.31270D-01  -0.23678D+00   0.23641D+00   0.83830D-01   0.21282D-01  -0.33862D-01
Shuttle Main Engine # 2           2243     0.32287D+00  -0.10464D+01  -0.13781D-01   0.70415D-01   0.43592D-01   0.27026D-01
Shuttle Main Engine # 3           2080     0.77004D-01  -0.10438D+01   0.58735D+00   0.61430D-01   0.47188D-01   0.22732D-01
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.35085D+00  -0.90658D+00   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.32948D+00   0.37847D+00   0.00000D+00   0.00000D+00   0.00000D+00
Left Coulomb  Damper (payload     3103     0.23867D+00   0.33521D-01  -0.80245D+00   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (payload      294     0.40691D+00   0.55176D-01   0.15496D+01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168     0.26793D+00   0.00000D+00   0.00000D+00   0.33594D-01   0.21569D-02  -0.24738D-01
Aft Payload Gyro (left)           2168     0.26793D+00   0.00000D+00   0.00000D+00   0.33594D-01   0.21569D-02  -0.24738D-01
Aft Payload Gyro (left)           2168     0.26793D+00   0.00000D+00   0.00000D+00   0.33594D-01   0.21569D-02  -0.24738D-01

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.64365D+00   0.27813D-01
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.64365D+00   0.27813D-01
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.35085D+00  -0.90658D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.32948D+00   0.37847D+00
Left Coulomb  Damper (payload     3103     0.23867D+00   0.33521D-01  -0.80245D+00
Right Coulomb Damper (payload      294     0.40691D+00   0.55176D-01   0.15496D+01
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.35085D+00  -0.90658D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.32948D+00   0.37847D+00
Left Coulomb  Damper (payload     3103     0.23867D+00   0.33521D-01  -0.80245D+00
Right Coulomb Damper (payload      294     0.40691D+00   0.55176D-01   0.15496D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00  -0.26957D-01  -0.88181D-02   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00   0.76195D+00   0.21991D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077     0.31270D-01  -0.23678D+00   0.23641D+00   0.83830D-01   0.21282D-01  -0.33862D-01

MODE #10/ 21, Frequency (rad/sec), Damping (zeta), Generalized Mass=    30.196       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077    -0.15782D+00  -0.86794D-01  -0.10225D+01   0.24476D-01  -0.69882D-01  -0.39828D-02
Shuttle Main Engine # 2           2243    -0.54192D+00  -0.31287D+00  -0.11424D+01   0.13103D-01  -0.40408D-01   0.10836D-01
Shuttle Main Engine # 3           2080    -0.59770D+00  -0.30187D+00  -0.10777D+01   0.20674D-01  -0.12082D+00   0.48907D-02
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.49082D-01   0.55420D+00   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.21449D+00   0.89783D+00   0.00000D+00   0.00000D+00   0.00000D+00
Left Coulomb  Damper (payload     3103    -0.13877D+01   0.60101D-01  -0.13049D+01   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (payload      294    -0.13652D+01  -0.28571D-01  -0.70263D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168    -0.11361D+01   0.00000D+00   0.00000D+00   0.10710D-01  -0.76235D-01   0.41165D-02
Aft Payload Gyro (left)           2168    -0.11361D+01   0.00000D+00   0.00000D+00   0.10710D-01  -0.76235D-01   0.41165D-02
Aft Payload Gyro (left)           2168    -0.11361D+01   0.00000D+00   0.00000D+00   0.10710D-01  -0.76235D-01   0.41165D-02

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.16460D+00   0.46871D+00
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.16460D+00   0.46871D+00
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.49082D-01   0.55420D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.21449D+00   0.89783D+00
Left Coulomb  Damper (payload     3103    -0.13877D+01   0.60101D-01  -0.13049D+01
Right Coulomb Damper (payload      294    -0.13652D+01  -0.28571D-01  -0.70263D+00
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.49082D-01   0.55420D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.21449D+00   0.89783D+00
Left Coulomb  Damper (payload     3103    -0.13877D+01   0.60101D-01  -0.13049D+01
Right Coulomb Damper (payload      294    -0.13652D+01  -0.28571D-01  -0.70263D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00  -0.12421D-01   0.27507D-01   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00   0.23220D+00  -0.58401D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077    -0.15782D+00  -0.86794D-01  -0.10225D+01   0.24476D-01  -0.69882D-01  -0.39828D-02

MODE #11/ 22, Frequency (rad/sec), Damping (zeta), Generalized Mass=    35.047       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077     0.72884D-01  -0.27897D-01   0.23937D+00  -0.39313D-02  -0.41623D-01  -0.35017D-02
Shuttle Main Engine # 2           2243    -0.25910D+00  -0.88788D-02   0.18625D+00  -0.42103D-02  -0.36970D-01   0.16362D-02
Shuttle Main Engine # 3           2080    -0.28079D+00  -0.89145D-02   0.16082D+00  -0.49393D-02  -0.21900D-01   0.23506D-02
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.36299D+00   0.77914D+00   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.39200D+00   0.74663D+00   0.00000D+00   0.00000D+00   0.00000D+00
Left Coulomb  Damper (payload     3103     0.82367D+00  -0.46137D-01  -0.60832D+00   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (payload      294     0.86059D+00   0.26589D-01  -0.65095D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168    -0.29042D+00   0.00000D+00   0.00000D+00  -0.13177D-01   0.93856D-02   0.28150D-01
Aft Payload Gyro (left)           2168    -0.29042D+00   0.00000D+00   0.00000D+00  -0.13177D-01   0.93856D-02   0.28150D-01
Aft Payload Gyro (left)           2168    -0.29042D+00   0.00000D+00   0.00000D+00  -0.13177D-01   0.93856D-02   0.28150D-01

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.45249D-02  -0.17132D+01
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.45249D-02  -0.17132D+01
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.36299D+00   0.77914D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.39200D+00   0.74663D+00
Left Coulomb  Damper (payload     3103     0.82367D+00  -0.46137D-01  -0.60832D+00
Right Coulomb Damper (payload      294     0.86059D+00   0.26589D-01  -0.65095D+00
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.36299D+00   0.77914D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.39200D+00   0.74663D+00
Left Coulomb  Damper (payload     3103     0.82367D+00  -0.46137D-01  -0.60832D+00
Right Coulomb Damper (payload      294     0.86059D+00   0.26589D-01  -0.65095D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00  -0.14557D-02   0.21755D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00   0.13421D-01  -0.15521D+01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077     0.72884D-01  -0.27897D-01   0.23937D+00  -0.39313D-02  -0.41623D-01  -0.35017D-02

MODE #12/ 24, Frequency (rad/sec), Damping (zeta), Generalized Mass=    36.204       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077     0.59830D+00  -0.47057D-01  -0.42961D+00   0.19626D-03   0.37200D-01   0.97680D-02
Shuttle Main Engine # 2           2243     0.92796D+00  -0.69439D-02  -0.34783D+00   0.40001D-03   0.35492D-01  -0.12467D-01
Shuttle Main Engine # 3           2080     0.95401D+00  -0.36175D-01  -0.43693D+00   0.92566D-02  -0.65166D-01   0.12542D-01
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.33628D+00   0.20026D+00   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.34576D+00   0.19389D+00   0.00000D+00   0.00000D+00   0.00000D+00
Left Coulomb  Damper (payload     3103    -0.15519D+01   0.98401D-01   0.22383D+00   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (payload      294    -0.16237D+01  -0.74423D-01   0.17232D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168     0.60376D+00   0.00000D+00   0.00000D+00   0.50016D-02   0.33940D-01   0.20816D-01
Aft Payload Gyro (left)           2168     0.60376D+00   0.00000D+00   0.00000D+00   0.50016D-02   0.33940D-01   0.20816D-01
Aft Payload Gyro (left)           2168     0.60376D+00   0.00000D+00   0.00000D+00   0.50016D-02   0.33940D-01   0.20816D-01

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00   0.47211D-01  -0.52876D+00
Orbiter IMU/Accelerom (right)     2311     0.00000D+00   0.47211D-01  -0.52876D+00
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.33628D+00   0.20026D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.34576D+00   0.19389D+00
Left Coulomb  Damper (payload     3103    -0.15519D+01   0.98401D-01   0.22383D+00
Right Coulomb Damper (payload      294    -0.16237D+01  -0.74423D-01   0.17232D+00
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.33628D+00   0.20026D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.34576D+00   0.19389D+00
Left Coulomb  Damper (payload     3103    -0.15519D+01   0.98401D-01   0.22383D+00
Right Coulomb Damper (payload      294    -0.16237D+01  -0.74423D-01   0.17232D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00  -0.80486D-02  -0.53624D-02   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00   0.44228D-01   0.50942D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077     0.59830D+00  -0.47057D-01  -0.42961D+00   0.19626D-03   0.37200D-01   0.97680D-02

MODE #13/ 25, Frequency (rad/sec), Damping (zeta), Generalized Mass=    37.357       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077     0.25305D-01  -0.68722D-02  -0.49114D+00  -0.69725D-03   0.14005D-01   0.24966D-02
Shuttle Main Engine # 2           2243     0.18722D+00   0.21098D-01  -0.41139D+00  -0.56621D-02   0.23886D-01  -0.83210D-02
Shuttle Main Engine # 3           2080     0.20817D+00   0.78025D-02  -0.49721D+00   0.34296D-02  -0.39715D-01   0.66426D-02
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.65895D-01  -0.14043D+00   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.67940D-01  -0.15793D+00   0.00000D+00   0.00000D+00   0.00000D+00
Left Coulomb  Damper (payload     3103     0.39525D+00  -0.29641D-01   0.27212D+00   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (payload      294     0.40171D+00   0.23070D-01   0.24116D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168    -0.95587D-02   0.00000D+00   0.00000D+00  -0.49934D-02   0.47939D-01   0.27668D-01
Aft Payload Gyro (left)           2168    -0.95587D-02   0.00000D+00   0.00000D+00  -0.49934D-02   0.47939D-01   0.27668D-01
Aft Payload Gyro (left)           2168    -0.95587D-02   0.00000D+00   0.00000D+00  -0.49934D-02   0.47939D-01   0.27668D-01

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.29168D-01  -0.65608D+00
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.29168D-01  -0.65608D+00
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.65895D-01  -0.14043D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.67940D-01  -0.15793D+00
Left Coulomb  Damper (payload     3103     0.39525D+00  -0.29641D-01   0.27212D+00
Right Coulomb Damper (payload      294     0.40171D+00   0.23070D-01   0.24116D+00
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.65895D-01  -0.14043D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.67940D-01  -0.15793D+00
Left Coulomb  Damper (payload     3103     0.39525D+00  -0.29641D-01   0.27212D+00
Right Coulomb Damper (payload      294     0.40171D+00   0.23070D-01   0.24116D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00   0.36148D-03  -0.20861D-01   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00  -0.87925D-03   0.74638D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077     0.25305D-01  -0.68722D-02  -0.49114D+00  -0.69725D-03   0.14005D-01   0.24966D-02

MODE #14/ 26, Frequency (rad/sec), Damping (zeta), Generalized Mass=    38.970       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077    -0.21105D+00   0.26981D-01   0.41088D+00   0.36845D-02  -0.96004D-02   0.98975D-02
Shuttle Main Engine # 2           2243    -0.12119D+00  -0.32273D-01   0.40495D+00   0.95190D-02   0.29471D-02   0.10823D-01
Shuttle Main Engine # 3           2080    -0.11881D+00  -0.19361D-01   0.39036D+00   0.10930D-01  -0.73495D-01  -0.53219D-02
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.37751D+00   0.87349D+00   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.41217D+00   0.93244D+00   0.00000D+00   0.00000D+00   0.00000D+00
Left Coulomb  Damper (payload     3103     0.68913D+00  -0.42505D-01  -0.40028D+00   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (payload      294     0.66791D+00   0.48459D-01  -0.32111D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168    -0.43715D+00   0.00000D+00   0.00000D+00   0.21175D-01  -0.26262D-01  -0.15911D-01
Aft Payload Gyro (left)           2168    -0.43715D+00   0.00000D+00   0.00000D+00   0.21175D-01  -0.26262D-01  -0.15911D-01
Aft Payload Gyro (left)           2168    -0.43715D+00   0.00000D+00   0.00000D+00   0.21175D-01  -0.26262D-01  -0.15911D-01

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.56598D-02  -0.19274D+01
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.56598D-02  -0.19274D+01
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.37751D+00   0.87349D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.41217D+00   0.93244D+00
Left Coulomb  Damper (payload     3103     0.68913D+00  -0.42505D-01  -0.40028D+00
Right Coulomb Damper (payload      294     0.66791D+00   0.48459D-01  -0.32111D+00
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.37751D+00   0.87349D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.41217D+00   0.93244D+00
Left Coulomb  Damper (payload     3103     0.68913D+00  -0.42505D-01  -0.40028D+00
Right Coulomb Damper (payload      294     0.66791D+00   0.48459D-01  -0.32111D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00  -0.21863D-02   0.13783D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00   0.15993D-01  -0.23633D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077    -0.21105D+00   0.26981D-01   0.41088D+00   0.36845D-02  -0.96004D-02   0.98975D-02

MODE #15/ 27, Frequency (rad/sec), Damping (zeta), Generalized Mass=    44.884       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077    -0.36983D-01   0.50700D+00  -0.52090D-01   0.13990D+00  -0.15859D-01   0.48133D-01
Shuttle Main Engine # 2           2243     0.22310D+00  -0.83586D+00  -0.68879D+00   0.15317D+00  -0.21086D-02   0.61760D-01
Shuttle Main Engine # 3           2080    -0.23870D+00  -0.80410D+00   0.59533D+00   0.11573D+00   0.38239D-01   0.26185D-01
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.79432D+00  -0.68423D+00   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.74820D+00   0.55900D+00   0.00000D+00   0.00000D+00   0.00000D+00
Left Coulomb  Damper (payload     3103     0.12333D+00   0.11691D+00  -0.22196D+01   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (payload      294    -0.11225D+00   0.12094D+00   0.22524D+01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168    -0.44172D-01   0.00000D+00   0.00000D+00   0.10972D+00   0.64790D-02   0.13682D-01
Aft Payload Gyro (left)           2168    -0.44172D-01   0.00000D+00   0.00000D+00   0.10972D+00   0.64790D-02   0.13682D-01
Aft Payload Gyro (left)           2168    -0.44172D-01   0.00000D+00   0.00000D+00   0.10972D+00   0.64790D-02   0.13682D-01

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.19556D-01   0.94448D-01
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.19556D-01   0.94448D-01
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.79432D+00  -0.68423D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.74820D+00   0.55900D+00
Left Coulomb  Damper (payload     3103     0.12333D+00   0.11691D+00  -0.22196D+01
Right Coulomb Damper (payload      294    -0.11225D+00   0.12094D+00   0.22524D+01
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.79432D+00  -0.68423D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.74820D+00   0.55900D+00
Left Coulomb  Damper (payload     3103     0.12333D+00   0.11691D+00  -0.22196D+01
Right Coulomb Damper (payload      294    -0.11225D+00   0.12094D+00   0.22524D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00  -0.18823D+00  -0.16900D-02   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00   0.14390D+01  -0.18145D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077    -0.36983D-01   0.50700D+00  -0.52090D-01   0.13990D+00  -0.15859D-01   0.48133D-01

MODE #16/ 28, Frequency (rad/sec), Damping (zeta), Generalized Mass=    45.938       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077    -0.11870D+01  -0.20272D-01  -0.36855D+00  -0.26053D-02   0.31919D-01   0.15618D-02
Shuttle Main Engine # 2           2243    -0.71934D+00  -0.44501D-02  -0.13602D+00  -0.18026D-01   0.74683D-01   0.18552D-02
Shuttle Main Engine # 3           2080    -0.68625D+00   0.15804D-01  -0.28210D+00   0.28585D-02  -0.32291D-02  -0.48943D-02
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.15863D+00  -0.78691D+00   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.26341D+00  -0.80468D+00   0.00000D+00   0.00000D+00   0.00000D+00
Left Coulomb  Damper (payload     3103     0.18365D+00  -0.82376D-01   0.53087D+00   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (payload      294     0.20189D+00   0.41006D-01   0.36799D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168    -0.83883D+00   0.00000D+00   0.00000D+00  -0.52451D-02   0.50702D-01   0.18619D-01
Aft Payload Gyro (left)           2168    -0.83883D+00   0.00000D+00   0.00000D+00  -0.52451D-02   0.50702D-01   0.18619D-01
Aft Payload Gyro (left)           2168    -0.83883D+00   0.00000D+00   0.00000D+00  -0.52451D-02   0.50702D-01   0.18619D-01

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.14036D+00   0.27867D+01
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.14036D+00   0.27867D+01
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.15863D+00  -0.78691D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.26341D+00  -0.80468D+00
Left Coulomb  Damper (payload     3103     0.18365D+00  -0.82376D-01   0.53087D+00
Right Coulomb Damper (payload      294     0.20189D+00   0.41006D-01   0.36799D+00
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.15863D+00  -0.78691D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.26341D+00  -0.80468D+00
Left Coulomb  Damper (payload     3103     0.18365D+00  -0.82376D-01   0.53087D+00
Right Coulomb Damper (payload      294     0.20189D+00   0.41006D-01   0.36799D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00   0.76833D-02  -0.21411D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00  -0.42301D-01   0.85213D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077    -0.11870D+01  -0.20272D-01  -0.36855D+00  -0.26053D-02   0.31919D-01   0.15618D-02

MODE #17/ 30, Frequency (rad/sec), Damping (zeta), Generalized Mass=    49.589       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077     0.25604D+00  -0.55772D+00  -0.23970D+00   0.65497D-01  -0.50926D-02   0.16175D-01
Shuttle Main Engine # 2           2243     0.43447D+00  -0.12293D+01  -0.44936D+00   0.41126D-01   0.68164D-02   0.58048D-01
Shuttle Main Engine # 3           2080    -0.15052D+00  -0.12472D+01  -0.55562D-01   0.56549D-01  -0.15260D-01   0.79674D-01
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.13747D+01  -0.87076D-01   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.12179D+01   0.29443D+00   0.00000D+00   0.00000D+00   0.00000D+00
Left Coulomb  Damper (payload     3103     0.25185D+00  -0.35391D+00   0.15955D+01   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (payload      294    -0.24547D+00  -0.37173D+00  -0.16973D+01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168     0.12473D+00   0.00000D+00   0.00000D+00   0.22300D-01  -0.15706D-01   0.66481D-01
Aft Payload Gyro (left)           2168     0.12473D+00   0.00000D+00   0.00000D+00   0.22300D-01  -0.15706D-01   0.66481D-01
Aft Payload Gyro (left)           2168     0.12473D+00   0.00000D+00   0.00000D+00   0.22300D-01  -0.15706D-01   0.66481D-01

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.45026D+01  -0.24365D+00
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.45026D+01  -0.24365D+00
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.13747D+01  -0.87076D-01
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.12179D+01   0.29443D+00
Left Coulomb  Damper (payload     3103     0.25185D+00  -0.35391D+00   0.15955D+01
Right Coulomb Damper (payload      294    -0.24547D+00  -0.37173D+00  -0.16973D+01
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.13747D+01  -0.87076D-01
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.12179D+01   0.29443D+00
Left Coulomb  Damper (payload     3103     0.25185D+00  -0.35391D+00   0.15955D+01
Right Coulomb Damper (payload      294    -0.24547D+00  -0.37173D+00  -0.16973D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00   0.50270D-01  -0.57957D-02   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00  -0.19717D+00   0.16050D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077     0.25604D+00  -0.55772D+00  -0.23970D+00   0.65497D-01  -0.50926D-02   0.16175D-01

MODE #18/ 31, Frequency (rad/sec), Damping (zeta), Generalized Mass=    50.285       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077    -0.56006D+00  -0.21116D+00   0.94354D+00   0.16136D-01   0.46841D-01   0.63211D-02
Shuttle Main Engine # 2           2243    -0.20709D+00  -0.41288D+00   0.92949D+00   0.14226D-01   0.51228D-01   0.15278D-01
Shuttle Main Engine # 3           2080    -0.37299D+00  -0.42062D+00   0.11249D+01   0.24302D-01   0.88822D-01   0.23393D-01
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.20591D+00  -0.46510D+00   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.53968D+00  -0.36984D+00   0.00000D+00   0.00000D+00   0.00000D+00
Left Coulomb  Damper (payload     3103     0.67690D-01  -0.12361D+00   0.75285D+00   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (payload      294    -0.10593D+00  -0.94208D-01  -0.27646D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168     0.20051D+00   0.00000D+00   0.00000D+00   0.15548D-01   0.64165D-01   0.30922D-01
Aft Payload Gyro (left)           2168     0.20051D+00   0.00000D+00   0.00000D+00   0.15548D-01   0.64165D-01   0.30922D-01
Aft Payload Gyro (left)           2168     0.20051D+00   0.00000D+00   0.00000D+00   0.15548D-01   0.64165D-01   0.30922D-01

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.12986D+01   0.54723D+00
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.12986D+01   0.54723D+00
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.20591D+00  -0.46510D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.53968D+00  -0.36984D+00
Left Coulomb  Damper (payload     3103     0.67690D-01  -0.12361D+00   0.75285D+00
Right Coulomb Damper (payload      294    -0.10593D+00  -0.94208D-01  -0.27646D+00
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.20591D+00  -0.46510D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.53968D+00  -0.36984D+00
Left Coulomb  Damper (payload     3103     0.67690D-01  -0.12361D+00   0.75285D+00
Right Coulomb Damper (payload      294    -0.10593D+00  -0.94208D-01  -0.27646D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00   0.85888D-02   0.48568D-01   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00  -0.35440D-01  -0.62447D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077    -0.56006D+00  -0.21116D+00   0.94354D+00   0.16136D-01   0.46841D-01   0.63211D-02

MODE #19/ 34, Frequency (rad/sec), Damping (zeta), Generalized Mass=    52.381       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077     0.29438D+00  -0.94330D-01  -0.71952D+00   0.57126D-02  -0.30132D-01   0.43522D-03
Shuttle Main Engine # 2           2243     0.45833D-01  -0.86562D-01  -0.74841D+00  -0.51439D-02  -0.26662D-01  -0.49572D-02
Shuttle Main Engine # 3           2080     0.57702D-01  -0.88218D-01  -0.75139D+00   0.11877D-02  -0.29531D-01   0.21323D-02
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.51897D-01  -0.11748D+00   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.73983D-01  -0.17906D+00   0.00000D+00   0.00000D+00   0.00000D+00
Left Coulomb  Damper (payload     3103     0.31226D-01   0.48579D-02   0.16648D+00   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (payload      294    -0.12257D-01  -0.48372D-02  -0.12871D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168    -0.10610D+00   0.00000D+00   0.00000D+00  -0.79441D-02  -0.14549D-01   0.90616D-02
Aft Payload Gyro (left)           2168    -0.10610D+00   0.00000D+00   0.00000D+00  -0.79441D-02  -0.14549D-01   0.90616D-02
Aft Payload Gyro (left)           2168    -0.10610D+00   0.00000D+00   0.00000D+00  -0.79441D-02  -0.14549D-01   0.90616D-02

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00   0.39641D-01   0.12090D+01
Orbiter IMU/Accelerom (right)     2311     0.00000D+00   0.39641D-01   0.12090D+01
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.51897D-01  -0.11748D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.73983D-01  -0.17906D+00
Left Coulomb  Damper (payload     3103     0.31226D-01   0.48579D-02   0.16648D+00
Right Coulomb Damper (payload      294    -0.12257D-01  -0.48372D-02  -0.12871D+00
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.51897D-01  -0.11748D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.73983D-01  -0.17906D+00
Left Coulomb  Damper (payload     3103     0.31226D-01   0.48579D-02   0.16648D+00
Right Coulomb Damper (payload      294    -0.12257D-01  -0.48372D-02  -0.12871D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00   0.67507D-02  -0.97767D-01   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00  -0.32811D-01   0.15234D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077     0.29438D+00  -0.94330D-01  -0.71952D+00   0.57126D-02  -0.30132D-01   0.43522D-03

MODE #20/ 36, Frequency (rad/sec), Damping (zeta), Generalized Mass=    54.582       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
