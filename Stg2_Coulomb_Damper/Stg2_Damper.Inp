Shuttle Main Engine # 1           2077     0.51608D-01  -0.10143D-02  -0.75586D+00   0.10606D-01  -0.20832D-01   0.34208D-02
Shuttle Main Engine # 2           2243     0.44531D-01  -0.51848D-01  -0.73710D+00   0.28644D-02  -0.31536D-02  -0.39218D-03
Shuttle Main Engine # 3           2080     0.70308D-01  -0.44862D-01  -0.75073D+00   0.53897D-02  -0.57048D-01  -0.25678D-02
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.64859D+00   0.79024D-01   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.59677D+00   0.11936D+00   0.00000D+00   0.00000D+00   0.00000D+00
Left Coulomb  Damper (payload     3103    -0.11252D-01  -0.16328D-01  -0.13835D+00   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (payload      294    -0.28510D-01  -0.31275D-02  -0.11767D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168    -0.31574D+00   0.00000D+00   0.00000D+00   0.99252D-02  -0.61601D-01  -0.94829D-02
Aft Payload Gyro (left)           2168    -0.31574D+00   0.00000D+00   0.00000D+00   0.99252D-02  -0.61601D-01  -0.94829D-02
Aft Payload Gyro (left)           2168    -0.31574D+00   0.00000D+00   0.00000D+00   0.99252D-02  -0.61601D-01  -0.94829D-02

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.20465D+00  -0.41239D+00
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.20465D+00  -0.41239D+00
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.64859D+00   0.79024D-01
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.59677D+00   0.11936D+00
Left Coulomb  Damper (payload     3103    -0.11252D-01  -0.16328D-01  -0.13835D+00
Right Coulomb Damper (payload      294    -0.28510D-01  -0.31275D-02  -0.11767D+00
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.64859D+00   0.79024D-01
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.59677D+00   0.11936D+00
Left Coulomb  Damper (payload     3103    -0.11252D-01  -0.16328D-01  -0.13835D+00
Right Coulomb Damper (payload      294    -0.28510D-01  -0.31275D-02  -0.11767D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00   0.12385D-02  -0.70674D-01   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00   0.41083D-02   0.35983D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077     0.51608D-01  -0.10143D-02  -0.75586D+00   0.10606D-01  -0.20832D-01   0.34208D-02

MODE #21/ 37, Frequency (rad/sec), Damping (zeta), Generalized Mass=    55.120       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077    -0.14493D-01   0.17632D+00  -0.41399D-01   0.10159D+00  -0.10844D-01   0.46025D-01
Shuttle Main Engine # 2           2243     0.24821D+00  -0.82128D+00  -0.49508D+00   0.10961D+00  -0.38981D-02   0.58937D-01
Shuttle Main Engine # 3           2080    -0.20563D+00  -0.80202D+00   0.43250D+00   0.90864D-01   0.25313D-01   0.38550D-01
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.20303D+00  -0.56069D+00   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.24395D+00   0.45832D+00   0.00000D+00   0.00000D+00   0.00000D+00
Left Coulomb  Damper (payload     3103     0.33028D+00  -0.41925D+00  -0.36284D+01   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (payload      294    -0.35413D+00  -0.41786D+00   0.37956D+01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168    -0.54688D-02   0.00000D+00   0.00000D+00   0.58516D-01   0.16168D-02   0.29611D-01
Aft Payload Gyro (left)           2168    -0.54688D-02   0.00000D+00   0.00000D+00   0.58516D-01   0.16168D-02   0.29611D-01
Aft Payload Gyro (left)           2168    -0.54688D-02   0.00000D+00   0.00000D+00   0.58516D-01   0.16168D-02   0.29611D-01

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00   0.32003D+01  -0.29711D-01
Orbiter IMU/Accelerom (right)     2311     0.00000D+00   0.32003D+01  -0.29711D-01
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.20303D+00  -0.56069D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.24395D+00   0.45832D+00
Left Coulomb  Damper (payload     3103     0.33028D+00  -0.41925D+00  -0.36284D+01
Right Coulomb Damper (payload      294    -0.35413D+00  -0.41786D+00   0.37956D+01
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.20303D+00  -0.56069D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.24395D+00   0.45832D+00
Left Coulomb  Damper (payload     3103     0.33028D+00  -0.41925D+00  -0.36284D+01
Right Coulomb Damper (payload      294    -0.35413D+00  -0.41786D+00   0.37956D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00   0.16515D+00   0.61373D-02   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00  -0.32249D+00  -0.38572D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077    -0.14493D-01   0.17632D+00  -0.41399D-01   0.10159D+00  -0.10844D-01   0.46025D-01

MODE #22/ 38, Frequency (rad/sec), Damping (zeta), Generalized Mass=    58.167       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077    -0.14701D-02  -0.24781D+00   0.14980D-01   0.27984D-01  -0.28315D-02   0.10913D+00
Shuttle Main Engine # 2           2243     0.10759D+00  -0.33897D+00  -0.33573D+00   0.71267D-01  -0.59820D-01   0.30961D-01
Shuttle Main Engine # 3           2080    -0.88700D-01  -0.32381D+00   0.32759D+00   0.62750D-01   0.25175D-01   0.15868D-01
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.53849D+00   0.60425D+00   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.59540D+00  -0.60684D+00   0.00000D+00   0.00000D+00   0.00000D+00
Left Coulomb  Damper (payload     3103     0.26223D+00   0.50936D+00   0.27123D+01   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (payload      294    -0.23412D+00   0.50946D+00  -0.28773D+01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168     0.16655D-01   0.00000D+00   0.00000D+00   0.88370D-02  -0.73775D-02   0.13486D-01
Aft Payload Gyro (left)           2168     0.16655D-01   0.00000D+00   0.00000D+00   0.88370D-02  -0.73775D-02   0.13486D-01
Aft Payload Gyro (left)           2168     0.16655D-01   0.00000D+00   0.00000D+00   0.88370D-02  -0.73775D-02   0.13486D-01

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.10245D+01   0.21422D+00
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.10245D+01   0.21422D+00
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.53849D+00   0.60425D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.59540D+00  -0.60684D+00
Left Coulomb  Damper (payload     3103     0.26223D+00   0.50936D+00   0.27123D+01
Right Coulomb Damper (payload      294    -0.23412D+00   0.50946D+00  -0.28773D+01
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.53849D+00   0.60425D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.59540D+00  -0.60684D+00
Left Coulomb  Damper (payload     3103     0.26223D+00   0.50936D+00   0.27123D+01
Right Coulomb Damper (payload      294    -0.23412D+00   0.50946D+00  -0.28773D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00  -0.24683D-01   0.26893D-02   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00  -0.75467D-01  -0.17307D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077    -0.14701D-02  -0.24781D+00   0.14980D-01   0.27984D-01  -0.28315D-02   0.10913D+00

MODE #23/ 39, Frequency (rad/sec), Damping (zeta), Generalized Mass=    58.496       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077     0.10614D-01  -0.81333D-01  -0.18310D-01  -0.59039D-01   0.10289D-01   0.23912D-01
Shuttle Main Engine # 2           2243    -0.13803D+00   0.62662D+00   0.13830D+00  -0.46006D-01  -0.31123D-01  -0.33395D-01
Shuttle Main Engine # 3           2080     0.13465D+00   0.60937D+00  -0.20459D+00  -0.18091D-01  -0.30017D-01  -0.12745D-01
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.15716D+00   0.81268D-01   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.18421D+00  -0.56868D-01   0.00000D+00   0.00000D+00   0.00000D+00
Left Coulomb  Damper (payload     3103     0.58816D+00  -0.11094D+01  -0.79525D+01   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (payload      294    -0.67776D+00  -0.11097D+01   0.86217D+01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168     0.17176D-01   0.00000D+00   0.00000D+00  -0.65772D-02   0.41605D-02   0.10579D-01
Aft Payload Gyro (left)           2168     0.17176D-01   0.00000D+00   0.00000D+00  -0.65772D-02   0.41605D-02   0.10579D-01
Aft Payload Gyro (left)           2168     0.17176D-01   0.00000D+00   0.00000D+00  -0.65772D-02   0.41605D-02   0.10579D-01

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.35662D+01  -0.15911D-01
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.35662D+01  -0.15911D-01
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.15716D+00   0.81268D-01
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.18421D+00  -0.56868D-01
Left Coulomb  Damper (payload     3103     0.58816D+00  -0.11094D+01  -0.79525D+01
Right Coulomb Damper (payload      294    -0.67776D+00  -0.11097D+01   0.86217D+01
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.15716D+00   0.81268D-01
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.18421D+00  -0.56868D-01
Left Coulomb  Damper (payload     3103     0.58816D+00  -0.11094D+01  -0.79525D+01
Right Coulomb Damper (payload      294    -0.67776D+00  -0.11097D+01   0.86217D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00   0.14815D-01   0.37777D-04   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00   0.84655D-01   0.11610D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077     0.10614D-01  -0.81333D-01  -0.18310D-01  -0.59039D-01   0.10289D-01   0.23912D-01

MODE #24/ 40, Frequency (rad/sec), Damping (zeta), Generalized Mass=    59.469       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077    -0.89627D-01  -0.16495D-01  -0.12190D+00   0.24610D-02  -0.17442D-01   0.27697D-02
Shuttle Main Engine # 2           2243    -0.22823D+00  -0.34681D-01  -0.13660D+00  -0.36665D-02  -0.10906D-01   0.34988D-02
Shuttle Main Engine # 3           2080    -0.23584D+00  -0.19680D-01  -0.98159D-01   0.33197D-02   0.13435D-01  -0.33227D-02
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.64701D+00  -0.85424D-01   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.58922D+00  -0.14735D+00   0.00000D+00   0.00000D+00   0.00000D+00
Left Coulomb  Damper (payload     3103     0.35601D-01   0.24592D-01  -0.36272D-01   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (payload      294     0.15401D-01   0.28685D-01  -0.17713D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168    -0.12017D+00   0.00000D+00   0.00000D+00  -0.92364D-02   0.44521D-02   0.11425D-01
Aft Payload Gyro (left)           2168    -0.12017D+00   0.00000D+00   0.00000D+00  -0.92364D-02   0.44521D-02   0.11425D-01
Aft Payload Gyro (left)           2168    -0.12017D+00   0.00000D+00   0.00000D+00  -0.92364D-02   0.44521D-02   0.11425D-01

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.24186D-01  -0.25808D+01
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.24186D-01  -0.25808D+01
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.64701D+00  -0.85424D-01
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.58922D+00  -0.14735D+00
Left Coulomb  Damper (payload     3103     0.35601D-01   0.24592D-01  -0.36272D-01
Right Coulomb Damper (payload      294     0.15401D-01   0.28685D-01  -0.17713D+00
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.64701D+00  -0.85424D-01
Right Coulomb Damper (vehicle     3101     0.00000D+00   0.58922D+00  -0.14735D+00
Left Coulomb  Damper (payload     3103     0.35601D-01   0.24592D-01  -0.36272D-01
Right Coulomb Damper (payload      294     0.15401D-01   0.28685D-01  -0.17713D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00   0.57097D-03  -0.12830D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00  -0.91464D-03   0.23361D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077    -0.89627D-01  -0.16495D-01  -0.12190D+00   0.24610D-02  -0.17442D-01   0.27697D-02

MODE #25/ 41, Frequency (rad/sec), Damping (zeta), Generalized Mass=    60.339       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077     0.43425D-02  -0.86613D-01   0.59078D-02  -0.37759D-01  -0.11263D-02   0.37862D-01
Shuttle Main Engine # 2           2243    -0.18305D-02   0.17674D+00   0.73040D-01  -0.22844D-01  -0.25255D-01   0.92273D-02
Shuttle Main Engine # 3           2080    -0.73074D-01   0.18150D+00  -0.94059D-01  -0.21166D-01   0.10647D-01   0.58832D-02
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.18301D+00   0.48237D+00   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.64300D-01  -0.42048D+00   0.00000D+00   0.00000D+00   0.00000D+00
Left Coulomb  Damper (payload     3103     0.23373D+00  -0.14347D+00  -0.11453D+01   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (payload      294    -0.25076D+00  -0.14392D+00   0.13207D+01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168    -0.22182D-01   0.00000D+00   0.00000D+00  -0.34784D-01  -0.45342D-02  -0.50390D-02
Aft Payload Gyro (left)           2168    -0.22182D-01   0.00000D+00   0.00000D+00  -0.34784D-01  -0.45342D-02  -0.50390D-02
Aft Payload Gyro (left)           2168    -0.22182D-01   0.00000D+00   0.00000D+00  -0.34784D-01  -0.45342D-02  -0.50390D-02

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00   0.20745D+00  -0.35726D+00
Orbiter IMU/Accelerom (right)     2311     0.00000D+00   0.20745D+00  -0.35726D+00
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.18301D+00   0.48237D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.64300D-01  -0.42048D+00
Left Coulomb  Damper (payload     3103     0.23373D+00  -0.14347D+00  -0.11453D+01
Right Coulomb Damper (payload      294    -0.25076D+00  -0.14392D+00   0.13207D+01
Left Coulomb Damper (vehicle s    3102     0.00000D+00  -0.18301D+00   0.48237D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.64300D-01  -0.42048D+00
Left Coulomb  Damper (payload     3103     0.23373D+00  -0.14347D+00  -0.11453D+01
Right Coulomb Damper (payload      294    -0.25076D+00  -0.14392D+00   0.13207D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00  -0.10610D+00  -0.33647D-01   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00  -0.43010D+00  -0.19340D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077     0.43425D-02  -0.86613D-01   0.59078D-02  -0.37759D-01  -0.11263D-02   0.37862D-01

MODE #26/ 62, Frequency (rad/sec), Damping (zeta), Generalized Mass=    77.760       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077    -0.11069D+00   0.50286D-01  -0.67912D+00   0.16962D-01  -0.13063D+00   0.13574D-01
Shuttle Main Engine # 2           2243    -0.30782D+00  -0.88994D-01  -0.66311D+00   0.19538D-01  -0.53210D-01   0.53399D-01
Shuttle Main Engine # 3           2080    -0.27750D+00   0.29005D-01  -0.60639D+00   0.16814D-04  -0.75458D-01  -0.51500D-01
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.15082D+01   0.91130D+00   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.15582D+01   0.96640D+00   0.00000D+00   0.00000D+00   0.00000D+00
Left Coulomb  Damper (payload     3103    -0.18392D+00  -0.93022D-02   0.24782D-01   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (payload      294    -0.20533D+00   0.32905D-02  -0.53602D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168    -0.59844D+00   0.00000D+00   0.00000D+00   0.18103D-01  -0.11358D+00  -0.22282D-01
Aft Payload Gyro (left)           2168    -0.59844D+00   0.00000D+00   0.00000D+00   0.18103D-01  -0.11358D+00  -0.22282D-01
Aft Payload Gyro (left)           2168    -0.59844D+00   0.00000D+00   0.00000D+00   0.18103D-01  -0.11358D+00  -0.22282D-01

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.41674D-01   0.22598D+00
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.41674D-01   0.22598D+00
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.15082D+01   0.91130D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.15582D+01   0.96640D+00
Left Coulomb  Damper (payload     3103    -0.18392D+00  -0.93022D-02   0.24782D-01
Right Coulomb Damper (payload      294    -0.20533D+00   0.32905D-02  -0.53602D-01
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.15082D+01   0.91130D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.15582D+01   0.96640D+00
Left Coulomb  Damper (payload     3103    -0.18392D+00  -0.93022D-02   0.24782D-01
Right Coulomb Damper (payload      294    -0.20533D+00   0.32905D-02  -0.53602D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00  -0.12077D-02   0.37632D-02   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00  -0.41493D-01  -0.67936D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077    -0.11069D+00   0.50286D-01  -0.67912D+00   0.16962D-01  -0.13063D+00   0.13574D-01

MODE #27/ 66, Frequency (rad/sec), Damping (zeta), Generalized Mass=    80.710       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077    -0.14921D+00  -0.23585D-01  -0.11554D+01   0.30392D-01  -0.84406D-01  -0.24377D-02
Shuttle Main Engine # 2           2243    -0.59040D+00  -0.23589D+00  -0.10232D+01  -0.25619D-01   0.75887D-02  -0.22969D-01
Shuttle Main Engine # 3           2080    -0.30654D+00  -0.17728D+00  -0.10203D+01   0.21306D-01  -0.62237D-01  -0.37877D-01
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.75397D+00   0.33353D+00   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.79364D+00   0.56166D+00   0.00000D+00   0.00000D+00   0.00000D+00
Left Coulomb  Damper (payload     3103    -0.66587D-01  -0.42497D-01   0.26919D+00   0.00000D+00   0.00000D+00   0.00000D+00
Right Coulomb Damper (payload      294    -0.10955D+00  -0.39905D-01  -0.23559D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168    -0.49964D+00   0.00000D+00   0.00000D+00   0.34194D-01  -0.11869D+00  -0.48166D-02
Aft Payload Gyro (left)           2168    -0.49964D+00   0.00000D+00   0.00000D+00   0.34194D-01  -0.11869D+00  -0.48166D-02
Aft Payload Gyro (left)           2168    -0.49964D+00   0.00000D+00   0.00000D+00   0.34194D-01  -0.11869D+00  -0.48166D-02

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.13455D+00   0.77291D-01
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.13455D+00   0.77291D-01
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.75397D+00   0.33353D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.79364D+00   0.56166D+00
Left Coulomb  Damper (payload     3103    -0.66587D-01  -0.42497D-01   0.26919D+00
Right Coulomb Damper (payload      294    -0.10955D+00  -0.39905D-01  -0.23559D+00
Left Coulomb Damper (vehicle s    3102     0.00000D+00   0.75397D+00   0.33353D+00
Right Coulomb Damper (vehicle     3101     0.00000D+00  -0.79364D+00   0.56166D+00
Left Coulomb  Damper (payload     3103    -0.66587D-01  -0.42497D-01   0.26919D+00
Right Coulomb Damper (payload      294    -0.10955D+00  -0.39905D-01  -0.23559D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00  -0.45156D-02   0.31170D-01   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00  -0.21761D+00   0.96747D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077    -0.14921D+00  -0.23585D-01  -0.11554D+01   0.30392D-01  -0.84406D-01  -0.24377D-02
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Plant Model, Vehicle/Actuators/Sensors                                                                                    
System
plant_flxcont.m
--------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Plant Model, Vehicle/Actuators/Sensors (Z-Transform T=0.04)                                                                                    
System
plant_flxz40ms.m
--------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Plant Model, Vehicle/Actuators/Sensors (Z-Transform T=0.002)                                                                                    
System
plant_flxz2ms.m
--------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Shuttle Stage-2 Continuous Flight Control System                                                                                    
System
controller_s
--------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Shuttle Stage-2 Discrete Flight Control System                                                                                    
System
controller_z
--------------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
